# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Delay.c Delay.h DS18B20.c DS18B20.h LCD1602.c LCD1602.h main.c Nixie.c Nixie.h OneWire.c OneWire.h Timer0.c Timer0.h
